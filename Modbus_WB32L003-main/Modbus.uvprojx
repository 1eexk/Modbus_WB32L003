# Keil uVision project Modbus.uvprojx, settings and files
target Modbus (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Clothes +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: WB32L003Fx,USE_STDPERIPH_DRIVER,MAINCLK_FREQ_HSI,HSI_VALUE=24000000
  c include: .\Libraries\CMSIS\Device\WB\WB32L003;.\Libraries\CMSIS\Include;.\Libraries\WB32L003_StdPeriph_Driver\inc;.\Utilities\Common;.\System;.\FreeModbus\modbus\ascii;.\FreeModbus\modbus\include;.\FreeModbus\modbus\rtu;.\FreeModbus\modbus;.\FreeModbus\port
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./Libraries/CMSIS/Device/WB/WB32L003/startup/arm/: startup_wb32l003.s
    ./Libraries/CMSIS/Device/WB/WB32L003/: system_wb32l003.c
    ./Libraries/WB32L003_StdPeriph_Driver/src/: wb32l003_flash.c wb32l003_iwdg.c
  group User
    ./: main.c
    ./Utilities/Common/: bsp_lpuart1.c Retarget_lpuart1.c
  group StdPeriph_Driver
    ./Libraries/WB32L003_StdPeriph_Driver/src/: wb32l003_gpio.c wb32l003_rcc.c wb32l003_adc.c wb32l003_tim.c wb32l003_basetim.c wb32l003_uart.c misc.c wb32l003_pca.c wb32l003_lpuart.c
  group System
    ./System/: user_mb_slave.c
  group modbus
    ./FreeModbus/modbus/: mb.c
    ./FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./FreeModbus/modbus/ascii/: mbascii.c
  group modbus_ports
    ./FreeModbus/port/: portevent.c portserial.c porttimer.c
